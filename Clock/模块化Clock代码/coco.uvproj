# Keil uVision project coco.uvproj, settings and files
target Clock (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: coco +hex
  c flags: Optimize=8 SizeSpeed=1
  group all of that
    ./: STARTUP.A51 delay.c main.c LCD.c keypad_scan.c ctrl_time.c set_time.c alarm.c clock.h
